# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\FreeRTOS\include;..\APP;..\HARDWARE\BSP\BSP_BOARD;..\HARDWARE\ABS\ABS_BOARD;..\HARDWARE\DRV\DRV_BOARD;..\HARDWARE\BSP\LED;..\HARDWARE\BSP\UART;..\HARDWARE\BSP\NVIC;..\HARDWARE\BSP\EXTI;..\HARDWARE\BSP\KEY;..\HARDWARE\ABS\TIMER;..\HARDWARE\ABS\KEY;..\HARDWARE\BSP\I2C;..\HARDWARE\BSP\SPI;..\HARDWARE\DRV\AT24CXX;..\HARDWARE\DRV\W25QXX;..\HARDWARE\DRV\OLED;..\HARDWARE\BSP\ADC;..\HARDWARE\BSP\TIM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group APP
    ../APP/: task_10ms.c task_10ms.h task_100ms.c task_100ms.h task_config.c task_config.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/: heap_4.c port.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group BSP
    ../HARDWARE/BSP/BSP_BOARD/: bsp_board.c bsp_board.h bsp_config.h
    ../HARDWARE/BSP/LED/: bsp_led.c bsp_led.h
    ../HARDWARE/BSP/NVIC/: bsp_nvic.c bsp_nvic.h
    ../HARDWARE/BSP/UART/: bsp_uart.c bsp_uart.h
    ../HARDWARE/BSP/EXTI/: bsp_exti.c bsp_exti.h
    ../HARDWARE/BSP/KEY/: bsp_key.c bsp_key.h
    ../HARDWARE/BSP/I2C/: bsp_i2c.c bsp_i2c.h
    ../HARDWARE/BSP/SPI/: bsp_spi.c bsp_spi.h
    ../HARDWARE/BSP/ADC/: bsp_adc.c bsp_adc.h
    ../HARDWARE/BSP/TIM/: bsp_tim.c bsp_tim.h
  group ABS
    ../HARDWARE/ABS/ABS_BOARD/: abs_board.c abs_board.h abs_config.h
    ../HARDWARE/ABS/TIMER/: abs_timer.c abs_timer.h
    ../HARDWARE/ABS/KEY/: abs_key.c abs_key.h abs_key_cfg.c abs_key_cfg.h abs_key_callback.c abs_key_callback.h
  group DRV
    ../HARDWARE/DRV/DRV_BOARD/: drv_board.c drv_board.h drv_config.h
    ../HARDWARE/DRV/AT24CXX/: drv_AT24CXX.c drv_AT24CXX.h
    ../HARDWARE/DRV/W25QXX/: drv_W25QXX.c drv_W25QXX.h
    ../HARDWARE/DRV/OLED/: drv_OLED.c drv_OLED.h drv_OLED_Data.c drv_OLED_Data.h
